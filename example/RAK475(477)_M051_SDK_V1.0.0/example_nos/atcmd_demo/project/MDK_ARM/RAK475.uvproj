# Keil uVision project RAK475.uvproj, settings and files
target RAK475 (5060020::V5.06 (build 20)::ARMCC)
  device: M058LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: RAK475_UART_DEMO
  c flags: wLevel=2
  c include: ..\..\..\..\platform\LibM051Series\CMSIS\CM0\CoreSupport;..\..\..\..\platform\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\..\..\..\platform\LibM051Series\StdDriver\inc;..\..\..\..\platform\bsp;..\..\..\..\uart_wifi_drv
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\output\RAK410_UART_TEST.sct
  group examples_nos/assist_atcmd_demo
    ../../src/: RAK_WIFI_Driver.c USER_APP_Task.c
    ../../../../: readme.txt
  group platform_nano100/bsp
    ../../../../platform/bsp/: BSP_Driver.c BSP_Init.c
  group platform_m051/libraries
    ../../../../platform/LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../platform/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../../../../platform/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
    ../../../../platform/LibM051Series/StdDriver/src/: retarget.c
  group uart_wifi_drv
    ../../../../uart_wifi_drv/: rak475_at_cmd.c utils.c
